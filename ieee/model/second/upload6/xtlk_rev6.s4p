# Hz S RI R 50
! Worked out from all points (4-port):
!   400 points, 50 MHz to 20 GHz, reference 50 ohm
!   strongest paths, dB at 50 MHz, 5.05 GHz, 10.05 GHz, 15.05 GHz, 20 GHz:
!     S43: -60.5, -39.9, -41.3, -44.8, -33.9
!     S21: -60.5, -39.9, -41.3, -44.8, -33.9
!     S42: -, -, -, -, -
!     S41: -, -, -, -, -
!     S32: -, -, -, -, -
!     S31: -, -, -, -, -
!   lowest |S11| = - dB at 50 MHz (marker M1), VSWR 1.00, Z = 50 + j0 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S43  S21
! 50 MHz  -60.5  -60.5
! 700 MHz  -41.1  -41.1
! 2.25 GHz  -51.3  -51.3
! 3.55 GHz  -34.5  -34.5
! 13.5 GHz  -27.1  -27.1
! 15.2 GHz  -46.2  -46.2
! 20 GHz  -33.9  -33.9
